# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051,USE_STM320518_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: .\src;.\lib\STM32F0xx_StdPeriph_Driver\inc;.\lib\CMSIS\Include;.\lib\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./src/: main.c stm32f0xx_it.c system_stm32f0xx.c uart.c HT1623.c LCD_HINORI.c spi.c
  group lib
    ./lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_exti.c stm32f0xx_dma.c
    ./lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
